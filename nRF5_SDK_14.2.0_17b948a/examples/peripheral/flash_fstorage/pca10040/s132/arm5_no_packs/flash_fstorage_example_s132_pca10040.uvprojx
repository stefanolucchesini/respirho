# Keil uVision project flash_fstorage_example_s132_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\components\libraries\cli\uart;..\..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\..\components\libraries\experimental_ringbuf;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\fprintf;..\config;..\..\..\..\..\..\..\..\..\AppData\Local\Arm\Packs\NordicSemiconductor\nRF_DeviceFamilyPack\8.38.0\Device\Include
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=5,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  asm include: ..\..\..\config;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\components\libraries\cli\uart;..\..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\..\components\libraries\experimental_ringbuf;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\fprintf;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x5d000
  memory RVCT9: RAM 0x200020e0 size 0xdf20
  link misc: --diag_suppress 6330
  group Application
    ../../../: cli.c main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../components/libraries/cli/: nrf_cli.c
    ../../../../../../components/libraries/cli/uart/: nrf_cli_uart.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../components/libraries/experimental_ringbuf/: nrf_ringbuf.c
    ../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../components/libraries/experimental_log/src/: nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
target flash_s132_nrf52_5.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.38.0
  cpu: as above
  output: s132_nrf52_5.0.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x5d000
  memory RVCT9: RAM 0x200020e0 size 0xdf20
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 4.3.0, Device:Startup 8.15.0
